# Keil uVision project CH559_IAP.uvproj, settings and files
target CH559 (MCS-51)
  device: SST89E564RD SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: CH559_IAP +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\Device;..\User\Host;..\User;..\User\PUB;..\User\PUB\INC
  group CH559_IAP
    ./: CH559_IAP.C
