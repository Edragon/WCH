# Keil uVision project USBH_MK_RE.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89x58RD SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x7FFF) CLOCK(40000000)
  output: USBH_MK_RE +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: USBH_MK_RE.C
