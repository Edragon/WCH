# Keil uVision project Simulation_9326.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: Simulation_9326 +hex
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: Simulation_9326.C
