# Keil uVision project usb_device_ch551.uvproj, settings and files
target usb_device_ch551 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: usb_device_ch551 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: xDEBUG
  link misc: removeunused
  group Source
    ./: GPIO.C UsbDescriptor.c Packet.c Task.c Usb.c Main.c System.c Uart.c RecvBuffer.c Interrupt.c Timer.c
  group Header
    ./: CH552.H Debug.H GPIO.H UsbDescriptor.h mcu.h Gpio_map.h Packet.h PinDefine.h Protocol.h Type.h UsbDef.h Task.h Usb.h System.h Uart.h RecvBuffer.h Timer.h
