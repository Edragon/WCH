# Keil uVision project oper_uart.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: oper_uart +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public
  group Source Group 1
    ./: main.c USBHOST_IF.C DataFlash_IF.C
    ./Public/: DEBUG.C
