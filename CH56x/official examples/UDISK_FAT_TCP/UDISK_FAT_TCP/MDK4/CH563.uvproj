# Keil uVision project CH563.uvproj, settings and files
target CH563 (ARM-ADS)
  device: STR912FAW44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: CH563 +hex
  c flags: Optim=3
  c include: ..\PUB;..\SRC;..\User;..\..\UDISK_FAT
  asm include: ..\..\..\sys
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: ..\SRC\CH563D64.SCF
  group User
    ../User/: CH563.C Udisk_FAT.C CH56XUFI_KIL31.LIB UDISK.C
    ../PUB/: EHCI_HCD.C CH563NET.lib
  group sys
    ../SRC/: STARTUP.S SYSFREQ.C
