# Keil uVision project CH563_Android.uvproj, settings and files
target CH563_Android (ARM-ADS)
  device: STR911FAM44 STMicroelectronics
  cpu: IRAM(0x04000000-0x04017FFF) IROM(0x0-0x7FFFF) IROM2(0x400000-0x407FFF) CLOCK(25000000) CPUTYPE(ARM966E-S)
  output: CH563_Android +hex
  c flags: Optim=3
  c include: .\myfile;.\myfile\OTG_Host;.\myfile\HUB;.\myfile\UDISK;.\myfile\HID;.\myfile\PA1200
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x400000 size 0x8000
  memory RVCT9: RAM 0x4000000 size 0x18000
  scatter file: .\myfile\CH563D64.SCF
  link misc: --entry 0x00000000
  group myfile
    ./myfile/: SYSFREQ.C STARTUP.S main.C EHCI_HCD.C
